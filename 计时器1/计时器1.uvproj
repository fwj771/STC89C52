# Keil uVision project 计时器1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 计时器1 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: removeunused
  group Source Group 1
    ./: DelayMs.c KeyScan.c LCD1602.c main.c MatrixKey.c Timer.c Buzzer.c
